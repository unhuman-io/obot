FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://obot-rt.cfg file://obot-can.cfg"
